Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-14T09:49:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jan 14 09:49:08 2024 * Host: LAPTOP-TVR8NT0T * Database: C:\Users\user\AppData\Local\Temp\cb292adb-013e-46ca-a64c-b5e7d75fd791\cde77ed8-084a-4791-bfa9-e0e0559dc20b\ifc * Database version: 5507 * Database creation date: Sun Jan 14 09:49:07 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jan 14 09:49:08 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jan 14 09:49:08 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: FFAS0703-102500BF0_REVIT:Neo Modern Extended Basin Mixer W/o PUW, FFAS0703-102500BF0_REVIT:Neo Modern Extended Basin Mixer W/o PUW:22311
In: Level 1
Type - Material: Steel, Chrome Plated
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Neo Modern Extended Basin Mixer W/o PUW
Pset_DistributionFlowElementCommon - Reference: Neo Modern Extended Basin Mixer W/o PUW; sets with these values: 2
